# IAR project Code.ewp, settings and files
configuration Code (ARM, debug)
  General.OGChipSelectEditMenu: STM32C011F4 ST STM32C011F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32C011xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32C0xx_HAL_Driver/Inc; ../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32C0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Code.hex
  ILINK.IlinkOutputFile: Code.out
  ILINK.IlinkIcfFile: stm32c011xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32c011xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_adc.c stm32c0xx_hal_adc_ex.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_cortex.c stm32c0xx_hal_exti.c stm32c0xx_hal_spi.c stm32c0xx_hal_spi_ex.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
